# Keil uVision project alarm_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: alarm_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD1602.c main.c Event_control.c display_manage.c Timer.c timer_manage.c display_manage.h event.h LCD1602.h timer.h timer_manage.h keypad.c Delay.c Delay.h keypad.h alarm_manage.c alarm_manage.h buzzer.c buzzer.h number_input.c number_input.h menu_manage.c menu_manage.h stopwatch_manage.c stopwatch_manage.h i2c_hal.c i2c_hal.h DS3231.C DS3231.h AT24C32.C AT24C32.H watch_dog.c watch_dog.h
